# Keil uVision project Control.uvproj, settings and files
target Simulator (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\driver;.\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ./src/: startup_LPC11xx.s
    ./lib/CMSISv2p00_LPC11xx/src/: system_LPC11xx.c
  group Config
    ./config/: driver_config.h target_config.h application.h
    ./lib/CMSISv2p00_LPC11xx/inc/: LPC11xx.h core_cm0.h
  group Source Files
    ./src/: Main.c uart.c
  group driver
    ./driver/: i2c.c gpio.c
    ./src/: lm75a.c
target LPC1114 RAM (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DEBUG__
  c include: .\config;.\driver;.\src
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1c00
  memory RVCT9: RAM 0x10001c00 size 0x400
target LPC1114 Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DEBUG__ __MASTER__
  c include: .\config;.\lib\CMSISv2p00_LPC11xx\inc;.\src;.\driver;.\.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
